# Keil uVision project Servo-F407.uvprojx, settings and files
target Servo-F407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Servo-F407 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Inc;                                           ../Drivers/STM32F4xx_HAL_Driver/Inc;                                           ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                           ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                           ../Drivers/CMSIS/Include;                                           ..\HARDWARE\motor;                                           ..\HARDWARE\MLX90614;                                           ..\HARDWARE\Linefinder;                                           ..\HARDWARE\control;                                           ..\HARDWARE\uart;                                           ..\HARDWARE\VL53L0X\core;                                           ..\HARDWARE\VL53L0X\platform;                                           ..\HARDWARE\BPSim;                                           ..\HARDWARE\sys
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Systeam
    ../Systeam/delay/: delay.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Hardware
    ../HARDWARE/MLX90614/: mlx90614.c
    ../HARDWARE/control/: control.c
    ../HARDWARE/uart/: uart_handler.c
  group BPSim
    ../HARDWARE/BPSim/: BPSim.c
software components: CMSIS:CORE 4.3.0
